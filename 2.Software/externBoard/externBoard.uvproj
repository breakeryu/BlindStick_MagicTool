# Keil uVision project externBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: externBoard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\Mid_Driver;.\Mid_Driver\inc
  group Source Group 1
    ./: STARTUP.A51
  group Mid_Driver
    ./Mid_Driver/src/: gpio.c
  group App
    ./App/: main.c
